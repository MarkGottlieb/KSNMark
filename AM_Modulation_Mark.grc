options:
  parameters:
    author: OE7WPA, Werner Pichl
    description: Simple AM Modulation
    generate_options: qt_gui
    id: AM_Modulation
    output_language: python
    title: AM Modulation
  states: {}

blocks:
- name: Frequency1
  id: variable_qtgui_range
  parameters:
    label: 'High Frequency '
    start: '10'
    step: '1'
    stop: '20000'
    value: '8000'
  states: {}
- name: Frequency2
  id: variable_qtgui_range
  parameters:
    label: Low Frequency
    start: '1'
    step: '1'
    stop: '500'
    value: '100'
  states: {}
- name: Modulation
  id: variable_qtgui_range
  parameters:
    label: Modulation
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: Volume
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.02'
    stop: '1'
    value: '0.1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: Frequency1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: Modulation
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/mark.gottlieb/Downloads/gong.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
